DESCRIPTION = "The Gumstix XBMC image.  This provides HTPC functionality through X11"
LICENSE = "MIT"

IMAGE_FEATURES += "x11"

require gumstix-console-image.bb



